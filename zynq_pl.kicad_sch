File: zynq_pl.kicad_sch (KiCad schematic)
At the start: 1 part, among them U1 XC7Z007S-1CLG225C

Commit message: Update zynq_pl page
Parts:
- added unit 8 of U1
